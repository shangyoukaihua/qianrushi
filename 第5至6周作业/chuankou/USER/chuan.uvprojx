# Keil uVision project chuan.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: chuan +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  c include: ..\SYSTEM-寄存器版\delay;..\SYSTEM-寄存器版\sys;..\SYSTEM-寄存器版\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    C:/Users/29541/Documents/C8T6点灯/启动文件/: startup_stm32f10x_md.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM-寄存器版/delay/: delay.c delay.h
    ../SYSTEM-寄存器版/sys/: sys.c sys.h
    ../SYSTEM-寄存器版/usart/: usart.c usart.h
